# Keil uVision project MyBlinkyKeil.uvprojx, settings and files
target MCBSTM32F200 (6240000::V6.24::ARMCLANG)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyBlinkyKeil
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: BlinkyLedKeil.c
software components: CMSIS:CORE 6.1.1, Device:STM32Cube Framework:Classic 1.2.8, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:Startup 2.2.2
